# Keil uVision project Gateway.uvprojx, settings and files
target Gateway (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Gateway +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Development/App;../Development/Com;../Development/Dri;../Development/Int;../Development/Int/Ethernet;../Development/Int/Ethernet/MQTT;../Development/Int/Ethernet/MQTT/MQTTPacket/src;../Development/Int/Ethernet/W5500;../Development/Mid;../Development/Mid/FreeRTOS;../Development/Mid/FreeRTOS/include;../Development/Mid/FreeRTOS/portable;../Development/Mid/FreeRTOS/portable/MemMang;../Development/Mid/FreeRTOS/portable/RVDS/ARM_CM3;../Development/Mid/FreeRTOS/source;../Development/Mid/Modbus_CRC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Development/App
    ../Development/App/: App_Task.c App_Task.h App_W5500.c App_W5500.h
  group Development/Com
    ../Development/Com/: Com_config.h Com_Debug.c Com_Debug.h Com_Util.c Com_Util.h cJSON.c cJSON.h
  group Development/Int
    ../Development/Int/: Int_W5500.c Int_W5500.h Int_Modbus.c Int_Modbus.h
  group Development/int/Ethernet
    ../Development/Int/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
  group Development/int/Ethernet/MQTT
    ../Development/Int/Ethernet/MQTT/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h
    ../Development/Int/Ethernet/MQTT/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group Development/int/Ethernet/W5500
    ../Development/Int/Ethernet/W5500/: dhcp.c dhcp.h dns.c dns.h httpParser.c httpParser.h httpServer.c httpServer.h httpUtil.c httpUtil.h w5500.c w5500.h
  group Development/Mid/FreeRTOS
    ../Development/Mid/FreeRTOS/: FreeRTOSConfig.h
    ../Development/Mid/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ../Development/Mid/FreeRTOS/portable/MemMang/: heap_4.c
    ../Development/Mid/FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../Development/Mid/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Development/Mid/Modbus_CRC
    ../Development/Mid/Modbus_CRC/: mbcrc.c mbcrc.h
software components: CMSIS:CORE 4.3.0
